# Keil uVision project USART.uvprojx, settings and files
target USART (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00040000) IRAM(0x20000000,0x0000C000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USART +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\BEEP;..\HARDWARE\HW;..\HARDWARE\LED;..\HARDWARE\SPI;..\HARDWARE\TIMER;..\HARDWARE\UHF;..\HARDWARE\W25QXX;..\HARDWARE\W5500;..\HARDWARE\SCREEN\inc;..\HARDWARE\WDG;..\HARDWARE\UHF
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/HW/: UHFhw_config.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/UHF/: uhf.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/W5500/: W5500.c
    ../HARDWARE/WDG/: wdg.c
  group SCREEN
    ../HARDWARE/SCREEN/src/: cmd_queue.c hmi_driver.c hmi_user_uart.c hw_config.c Screen.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_wwdg.c stm32f10x_iwdg.c
  group README
    ../: README.TXT
software components: CMSIS:CORE 4.3.0
